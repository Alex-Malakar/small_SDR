options:
  parameters:
    author: Alex
    generate_options: qt_gui
    id: decode_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_dec
  id: variable_qtgui_range
  parameters:
    label: audio_decimator
    start: '1'
    step: '1'
    stop: '48'
    value: '1'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 90e6
    step: 100e3
    stop: 110e6
    value: 102.7e6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 70e6
  states: {}
- name: gain_volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '35'
  states: {}
- name: lp_fc
  id: variable_qtgui_range
  parameters:
    label: Lowpass Cutoff Frequency
    start: 70e3
    step: 5e3
    stop: 100e3
    value: 70e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_fc
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
